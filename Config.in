## package/helloworld/Config.in
```kconfig
config BR2_PACKAGE_HELLOWORLD
       bool "helloworld-app"
       help
        A classic C hello-world application
```
